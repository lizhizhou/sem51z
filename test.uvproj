# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F120 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: test
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c T6963.C uart.c ADC0.c DAC.c delay.c init.c PNL_30A.c key_map.c brushlessmotor.c
